SRC_URI = "file://enable-autofs4.cfg"

KERNEL_FEATURES += "features/cgroups/cgroups.cfg"
