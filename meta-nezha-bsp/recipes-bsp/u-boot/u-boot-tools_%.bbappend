SRC_URI = "git://github.com/Cezarus27/u-boot.git;protocol=git;branch=d1-wip"
SRCREV = "d4270eaf8c0b06fe28059188d5e7c13b5c0c6b81"
